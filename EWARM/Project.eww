<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LAB5CH3F100.ewp</path>
  </project>
  <batchBuild />
</workspace>
